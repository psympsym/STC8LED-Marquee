# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./User/: Main.c
    ./User/src/: Init.c KeyScan.c KeyServices.c LEDChange.c NixieTube.c Timing.c
